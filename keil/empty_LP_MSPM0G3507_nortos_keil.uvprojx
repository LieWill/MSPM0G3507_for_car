# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  BeforeMake: cmd.exe /C "D:\ti\mspm0_sdk_2_04_00_06\tools\keil\syscfg.bat '$P' TEMPLATE.syscfg"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: D:\ti\mspm0_sdk_2_04_00_06\source\third_party\CMSIS\Core\Include;D:\ti\mspm0_sdk_2_04_00_06\source;..\USER;..\BSP\OLED;..\BSP\VOFA;..\BSP\Motor;..\BSP\PID;..\BSP\WIT;..\BSP\TIMER;..\BSP\RIF;..\BSP\QEI;..\BSP\FLASH;..\BSP\TASK
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  group Source
    ./: startup_mspm0g350x_uvision.s
    ../USER/: main.c ti_msp_dl_config.c ti_msp_dl_config.h
    ./: TEMPLATE.syscfg
  group lib
    D:/ti/mspm0_sdk_2_04_00_06/source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
    D:/ti/mspm0_sdk_2_04_00_06/source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
  group OLED
    ../../BSP/OLED/: oled.c OLED.H
  group VOFA
    ../../BSP/VOFA/: vofa.c vofa.h
  group Motor
    ../BSP/Motor/: motor.h motor.c
  group PID
    ../BSP/PID/: pid.c pid.h
  group RIF
    ../BSP/RIF/: rif.c rif.h
  group WIT
    ../BSP/WIT/: wit.h wit.c
  group TIMER
    ../BSP/TIMER/: timer.c timer.h
  group QEI
    ../BSP/QEI/: qei.c qei.h
  group FLASH
    ../BSP/FLASH/: flash.c flash.h
  group TASK
    ../BSP/TASK/: task.c task.h
